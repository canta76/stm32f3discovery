# Keil uVision project IMU.uvproj, settings and files
target IMU (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: IMU
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,UVISION
  c include: .;..\..\..\lib;..\..\..\lib\board;..\..\..\lib\imu;..\..\..\lib\STM32F30x_StdPeriph_Driver\inc;..\..\..\lib\CMSIS\Include;..\..\..\lib\CMSIS\Device\ST\STM32F30x\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group board
    ./../../../lib/board/: imu_devs.c hw_config.c key.c leds.c serial.c stm32f3_discovery.c stm32f3_discovery_l3gd20.c stm32f3_discovery_lsm303dlhc.c stm32f30x_it.c system_stm32f30x.c startup.s
    ../../../lib/board/: syscalls.c
  group STM32F30x_StdPeriph_Driver
    ./../../../lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group main
    ./../: demos.c main.c
  group imu
    ./../../../lib/imu/: imu_util.c KalmanAHRS.c MadgwickAHRS.c MadgwickFullAHRS.c MahonyAHRS.c
